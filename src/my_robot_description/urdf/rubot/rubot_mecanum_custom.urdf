Commit message: canvis act2

File: src/my_robot_description/urdf/rubot/rubot_mecanum_custom.urdf (robot description, URDF)
Before this commit: robot rubot, 10 links, 9 joints
Links:
- removed link my_extra_part
Joints:
- removed joint joint_my_extra_part
