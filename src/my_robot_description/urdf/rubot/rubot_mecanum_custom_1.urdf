Commit message: lab

File: src/my_robot_description/urdf/rubot/rubot_mecanum_custom_1.urdf (robot description, URDF)
Before this commit: robot rubot, 9 links, 8 joints
Joints:
- joint scan_joint: origin xyz=0 0 0.14 rpy=0 0 3.14 -> xyz=0 0 0.14 rpy=0 0 0
